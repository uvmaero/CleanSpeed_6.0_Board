File: Big Daddy/High Voltage.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: Updated BOM
Other:
- note added: "high voltage"
